# IAR project Certificate_Signing_Request_CC3235SF_LAUNCHXL_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Certificate_Signing_Request_CC3235SF_LAUNCHXL_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
