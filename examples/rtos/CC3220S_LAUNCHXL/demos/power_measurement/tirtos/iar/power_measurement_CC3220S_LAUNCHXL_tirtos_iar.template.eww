<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/power_measurement_CC3220S_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <project>
    <path>$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC3220S_LAUNCHXL/release/iar/tirtos_builds_CC3220S_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
