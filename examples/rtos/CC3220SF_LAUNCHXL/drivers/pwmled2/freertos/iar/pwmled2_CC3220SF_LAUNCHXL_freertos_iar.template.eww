<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/pwmled2_CC3220SF_LAUNCHXL_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/freertos/builds/CC3220SF_LAUNCHXL/release/iar/freertos_builds_CC3220SF_LAUNCHXL_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>