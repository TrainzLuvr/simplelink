<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/local_time_CC3235SF_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <project>
    <path>$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC3235SF_LAUNCHXL/release/iar/tirtos_builds_CC3235SF_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
